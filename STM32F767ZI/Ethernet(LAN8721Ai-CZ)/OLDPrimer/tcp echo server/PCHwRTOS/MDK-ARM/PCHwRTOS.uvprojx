# Keil uVision project PCHwRTOS.uvprojx, settings and files
target PCHwRTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: PCHwRTOS +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx
  c misc: --C99
  c include: ../Inc;                ../Middlewares/Third_Party/LwIP/src/include;                ../Middlewares/Third_Party/LwIP/system;                ../Drivers/STM32F7xx_HAL_Driver/Inc;                ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;                ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;                ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;                ../Middlewares/Third_Party/LwIP/src/include/lwip;                ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;                ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;                ../Middlewares/Third_Party/LwIP/src/include/lwip/prot;                ../Middlewares/Third_Party/LwIP/src/include/netif;                ../Middlewares/Third_Party/LwIP/src/include/posix;                ../Middlewares/Third_Party/LwIP/src/include/posix/sys;                ../Middlewares/Third_Party/LwIP/system/arch;                ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f7xx_it.c lwip.c stm32f7xx_hal_msp.c main.c ethernetif.c net.c
    ../Inc/: net.h
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/: netif.c mem.c memp.c init.c stats.c tcp.c sys.c tcp_out.c pbuf.c inet_chksum.c ip.c raw.c udp.c tcp_in.c timeouts.c def.c dns.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: inet6.c mld6.c ip6.c ethip6.c dhcp6.c ip6_frag.c ip6_addr.c icmp6.c nd6.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4_addr.c ip4_frag.c dhcp.c ip4.c etharp.c igmp.c autoip.c icmp.c
    ../Middlewares/Third_Party/LwIP/src/api/: tcpip.c err.c api_msg.c api_lib.c netbuf.c netdb.c sockets.c netifapi.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: vj.c pppoe.c magic.c ipcp.c pppol2tp.c ccp.c pppcrypt.c pppapi.c ecp.c upap.c auth.c eap.c ppp.c ipv6cp.c multilink.c utils.c chap-md5.c pppos.c chap_ms.c mppe.c chap-new.c fsm.c lcp.c eui64.c demand.c
    ../Middlewares/Third_Party/LwIP/src/netif/: slipif.c ethernet.c lowpan6.c
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_tim.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_pwr.c stm32f7xx_hal_dma.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal.c stm32f7xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
software components: CMSIS:CORE 5.0.2
